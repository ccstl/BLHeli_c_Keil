# Keil uVision project BLHeli_s.uvproj, settings and files
target EFM8BB21 (MCS-51)
  device: EFM8BB21F16G-QSOP24 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(50000000)
  output: BLHeli_s
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: SILABS_STARTUP.A51 main.c defs.h public.c
